# Keil uVision project 02.new.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F310C8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 02.new +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F3X0_LD
  c include: .\App\DataType;.\App\Main;.\App\LED;.\HW\RCU;.\HW\Timer;.\HW\UART0;.\FW\Include;.\ARM\NVIC;.\ARM\System;.\ARM\SysTick;.\App\SPO2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./App/Main/: Main.c
    ./App/SPO2/: SPO2_Driver.c
  group HW
    ./HW/RCU/: RCU.c
    ./HW/Timer/: Timer.c
    ./HW/UART0/: UART0.c
  group FW
    ./FW/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group ARM
    ./ARM/NVIC/: NVIC.c
    ./ARM/System/: gd32f3x0_it.c startup_gd32f3x0.s system_gd32f3x0.c
    ./ARM/SysTick/: SysTick.c
software components: CMSIS:CORE 6.1.1
