/*********************************************************************************************************
* 模块名称：SysTick.c
* 摘    要：SysTick模块，包含SysTick模块初始化以及微秒和毫秒级延时函数
* 当前版本：1.0.0
* 作    者：Leyutek(COPYRIGHT 2018 - 2021 Leyutek. All rights reserved.)
* 完成日期：2021年07月01日 
* 内    容：
* 注    意：                                                                  
**********************************************************************************************************
* 取代版本：
* 作    者：
* 完成日期：
* 修改内容：           
* 修改文件：
*********************************************************************************************************/

/*********************************************************************************************************
*                                              包含头文件
*********************************************************************************************************/
#include "SysTick.h"
#include "gd32f3x0_conf.h"

/*********************************************************************************************************
*                                              宏定义
*********************************************************************************************************/

/*********************************************************************************************************
*                                              枚举结构体
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部变量定义
*********************************************************************************************************/
static  __IO  unsigned int s_iTimDelayCnt = 0;

/*********************************************************************************************************
*                                              内部函数声明
*********************************************************************************************************/
/*
static  void TimDelayDec(void); //延时计数
*/

/*********************************************************************************************************
*                                              内部函数实现
*********************************************************************************************************/
/*********************************************************************************************************
* 函数名称：TimDelayDec
* 函数功能：延时计数  
* 输入参数：void
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：在SysTick中断服务函数SysTick_Handler中调用
*********************************************************************************************************/
void TimDelayDec(void)
{
  if(s_iTimDelayCnt != 0) //延时计数器的数值不为0
  {                       
    s_iTimDelayCnt--;     //延时计数器的数值减1
  }
}

/*********************************************************************************************************
* 函数名称：SysTick_Handler
* 函数功能：SysTick中断服务函数 
* 输入参数：void
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：
*********************************************************************************************************/
/*********************************************************************************************************
* 函数名称：SysTick_Handler
* 函数功能：SysTick中断服务函数 
* 输入参数：void
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：
*********************************************************************************************************/
void  SysTick_Handler(void)
{
  TimDelayDec();  //延时计数函数
}

/*********************************************************************************************************
*                                              API函数实现
*********************************************************************************************************/
/*********************************************************************************************************
* 函数名称：InitSysTick
* 函数功能：初始化SysTick模块  
* 输入参数：void  
* 输出参数：void  
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：SystemCoreClock / 1000      1ms中断一次（计数1000次为1s，每计一次位1/1000s=1ms）
*           SystemCoreClock / 4000      0.25ms中断一次（计数4000次为1s，每计一次位1/4000s=0.25ms）
*           SystemCoreClock / 100000    10us中断一次（计数100000次为1s，每计一次位1/100000s=10us）
*           SystemCoreClock / 1000000   1us中断一次（计数1000000次为1s，每计一次位1/1000000s=1us）
*********************************************************************************************************/
void InitSysTick( void )
{
  if (SysTick_Config(SystemCoreClock / 1000U)) //配置系统滴答定时器1ms中断一次  
  { 
    while(1)                                   //错误发生的情况下，进入死循环
    {
      
    }
  }
}

/*********************************************************************************************************
* 函数名称：DelayNms
* 函数功能：毫秒级延时函数  
* 输入参数：nms
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：
*********************************************************************************************************/
void  DelayNms(__IO unsigned int nms)
{
  // 简单的软件延时，不依赖任何外设，防止死锁
  // 假设主频72MHz，大概的循环次数
  volatile unsigned int i, j;
  for(i = 0; i < nms; i++)
  {
    for(j = 0; j < 7200; j++)
    {
       __NOP();
    }
  }
}

/*********************************************************************************************************
* 函数名称：DelayNus
* 函数功能：微秒级延时函数  
* 输入参数：nus
* 输出参数：void
* 返 回 值：void
* 创建日期：2021年07月01日
* 注    意：
*********************************************************************************************************/
void  DelayNus(__IO unsigned int nus)
{
  volatile unsigned int i, j;
  for(i = 0; i < nus; i++)
  {
    for(j = 0; j < 7; j++)
    {
       __NOP();
    }
  }
}
