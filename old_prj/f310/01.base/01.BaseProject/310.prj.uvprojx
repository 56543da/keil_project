# Keil uVision project 310.prj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F310C8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 310.prj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH,GD32F3x0_HD
  c include: .\App\Main;.\App\LED;.\App\DataType;.\HW\RCU;.\HW\Timer;.\HW\UART0;.\FW\Include;.\ARM\NVIC;.\ARM\System;.\ARM\SysTick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./App/Main/: Main.c
    ./App/LED/: LED.c
  group HW
    ./HW/RCU/: RCU.c
    ./HW/Timer/: Timer.c
    ./HW/UART0/: Queue.c UART0.c
  group FW
    ./FW/Source/: gd32f30x_usart.c gd32f30x_timer.c gd32f30x_rcu.c gd32f30x_misc.c gd32f30x_i2c.c gd32f30x_gpio.c gd32f30x_adc.c gd32f30x_dac.c
  group ARM
    ./ARM/NVIC/: NVIC.c
    ./ARM/System/: gd32f30x_it.c system_gd32f30x.c startup_gd32f30x_hd.s
    ./ARM/SysTick/: SysTick.c
software components: CMSIS:CORE 5.4.0
